# IAR project vcan_Kinetis.ewp, settings and files
configuration KEA128_Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZ128xxx4 Freescale KEAZ128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG_MODE; ARM_MATH_CM0PLUS; MKEA128
  ICCARM.CCIncludePath2: $PROJ_DIR$; config files; KEA128_Debug; KEA128_Debug\Exe; KEA128_Debug\List; KEA128_Debug\Obj; settings; ..\..\App; ..\..\App\Inc; ..\..\Board; ..\..\Board\inc; ..\..\Board\src; ..\..\Chip; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Chip\src; ..\..\Chip\src\IAR; ..\..\Lib; ..\..\Lib\CMSIS; ..\..\Lib\CMSIS\Inc; ..; $PROJ_DIR$; config files; KEA128_Debug; KEA128_Debug\Exe; KEA128_Debug\List; KEA128_Debug\Obj; settings; ..\..\settings; ..\..\vs; ..\..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vcan_Kinetis.sim
  ILINK.IlinkOutputFile: vcan_Kinetis.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Freescale\vcan_ROM_KEA128.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration KEA128_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: vcan_Kinetis.bin
  group App
    ../../App/: main.c MKEA128_conf.c MKEA128_it.c
    ../../App/Inc/: MKEA128_conf.h MKEA128_it.h PORT_cfg.h
    ../../Board/src/: mydata.c
    ../../../../2017.7.11 - 副本 (2)/: vcan_Kinetis.eww
  group Board
    ../../Board/src/: car_init_all.c car_motor.c car_sensor.c car_servo.c car_time_sign.c fuzzer.c VCAN_ASCII.c VCAN_computer.c VCAN_key.c VCAN_key_event.c VCAN_LCD.c VCAN_LCD_CH.c VCAN_LCD_ST7735R.c VCAN_LCD_ST7735S.c VCAN_LED.C VCAN_NRF24L0_MSG.c VCAN_TSL1401.c VCAN_UI_VAR.c
    ../../Board/inc/: car_struct.h
  group Chip
    ../../Chip/inc/: common.h
    ../../Chip/src/: KEA_adc.c KEA_ftm.c KEA_gpio.c KEA_PIT.c KEA_port.c KEA_SysTick.c KEA_uart.c KEA_wdog.c misc.c vectors.c
    ../../Chip/src/IAR/: startup_SKEAZ1284.s system_SKEAZ1284.c
    ../../Board/src/: VCAN_NRF24L0.c
